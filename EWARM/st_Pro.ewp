# IAR project st_Pro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\Drivers\CMSIS\Include; ..\Drivers\STM32F4xx_StdPeriph_Driver\inc; ..\Users; ..\Drivers\BSP; ..\Drivers\USB\inc; ..\Drivers\USB\STM32_USB_Device_Library\Class\CDC\Inc; ..\Drivers\USB\STM32_USB_Device_Library\Core\Inc; ..\Drivers\USB\STM32F4xx_HAL_Driver\inc; ..\Drivers\Soft
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: st_Pro.srec
  ILINK.IlinkOutputFile: st_Pro.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers/BSP
    ../Drivers/BSP/: bsp.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/SOFT
    ../Drivers/Soft/: porting_delay.c porting_tube.c
  group Drivers/ST_STD
    ../Drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c
  group Drivers/USB
    ../Drivers/USB/STM32F4xx_HAL_Driver/src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
    ../Drivers/USB/src/: usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
    ../Drivers/USB/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Drivers/USB/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group EWARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
  group Users
    ../Users/: main.c stm32f4xx_it.c
